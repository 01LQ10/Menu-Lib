# Keil uVision project 04_F103-MDK-0.uvprojx, settings and files
target 04_F103-MDK-0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 04_F103-MDK-0
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/LED;..\BSP\MutiButton;..\BSP\SSD1306;..\menu_interface;..\..\..\src;..\..\..\example_basic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c i2c.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group STARTUP
    ../Drivers/startup/: startup_stm32f103xb.s
  group LED
    ../BSP/LED/: LED.c LED_Drive.c
  group SSD1306
    ../BSP/SSD1306/: driver_ssd1306.c driver_ssd1306_advance.c driver_ssd1306_basic.c driver_ssd1306_interface.c
  group MENU
    ../../../src/: menu_core.c
    ../../../example_basic/: menu_basic.c
    ../menu_interface/: menu_interface.c
  group BUTN
    ../BSP/MutiButton/: multi_button.c MyButton.c MyButton_task.c
software components: CMSIS:CORE 4.3.0
